# IAR project flashflood_local.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LOCAL_SETUP; UART_HOP; LIGHTPIN_ALLMOTES; ENABLE_LEDS; ENABLE_DEBUGPINS; LINEAR_TOPOLOGY
  ICC430.newCCIncludePaths: ..\..\drivers
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../flashflood_testbed_production/: flashflood.c
  group drivers
    ../../drivers/: adc_sensor.c adc_sensor.h cc2420.c cc2420.h eui64.c eui64.h radio.c radio.h spi.c spi.h
