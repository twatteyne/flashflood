<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\00std_eui64_uart\00std_eui64_uart.ewp</path>
  </project>
  <batchBuild/>
</workspace>


