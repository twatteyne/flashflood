# IAR project ft_sync.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\drivers\board\; ..\..\drivers\cc2420\; ..\..\inc\; $PROJ_DIR$
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group bsp/board
    ../../drivers/board/: board.c board.h board_info.h bsp_timer.c bsp_timer.h debugpins.c debugpins.h eui64.c eui64.h leds.c leds.h radio.h radiotimer.c radiotimer.h spi.c spi.h toolchain_defs.h uart.c uart.h
  group bsp/cc2420
    ../../drivers/cc2420/: cc2420.c cc2420.h cc2420_crypto.c cc2420_crypto.h radio.c
  group inc
    ../../inc/: opendefs.h
  group project
    ./: ft_sync.c ft_sync.h
