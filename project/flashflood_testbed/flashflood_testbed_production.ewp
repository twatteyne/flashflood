# IAR project flashflood_testbed_production.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LIGHTPIN_ALLMOTES; UART_HOP
  ICC430.newCCIncludePaths: ..\..\drivers; ; ..\..\inc
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: flashflood.c
  group drivers
    ../../drivers/: adc_sensor.c adc_sensor.h cc2420.c cc2420.h eui64.c eui64.h radio.c radio.h spi.c spi.h timer_a.c timer_a.h timer_b.c timer_b.h
